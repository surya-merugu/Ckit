# IAR project conversion_kit.ewp, settings and files
configuration conversion_kit (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\Drivers\CMSIS\Core\Include; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Core_A\Include; ..\..\Drivers\CMSIS\DSP\Include; ..\..\Inc; ..\..\Inc\Inits; ..\..\Inc\ISR; ..\..\Inc\Modules; ..\..\Inc\SysConfig; ..\..\Middleware\Third_Party\FatFs\Src; ..\..\Inc\Inits\Fatfs_drivers; ..\..\Inc\Modules\main; ..\..\Inc\Inits; ..\..\Inc\ISR; ..\..\Inc\Modules; ..\..\Inc\SysConfig; ..\..\Inc\Modules\motor_temperature; ..\..\Src\Modules\motor_temperature
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: conversion_kit.hex
  ILINK.IlinkOutputFile: conversion_kit.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../../Src/SysConfig/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver/Inc
    ../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32_assert_template.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_smbus.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
  group Drivers/STM32F4xx_HAL_Driver/Src
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_rtc_alarm_template.c stm32f4xx_hal_timebase_rtc_wakeup_template.c stm32f4xx_hal_timebase_tim_template.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Inc
    ../../Inc/: bsp_driver_sd.h fatfs.h ffconf.h sd_diskio.h
  group Inc/Inits
    ../../Inc/Inits/: re_can_init.h re_dock_latch_init.h re_gear_init.h re_hal_msp.h re_i2c_init.h re_key_init.h re_lcd_gpio_init.h re_rev_light_init.h re_speed_init.h re_spi_init.h re_thc_off_init.h re_timer_init.h re_uart_init.h
  group Inc/ISR
    ../../Inc/ISR/: re_can_int_callback.h re_gpio_int_callback.h re_timer_int_callback.h stm32f4xx_it.h
  group Inc/Modules/battery_info
    ../../Inc/Modules/battery_info/: re_app_battery_info.h
  group Inc/Modules/dash_lcd
    ../../Inc/Modules/dash_lcd/: re_app_dash_lcd.h re_driver_dash_lcd.h
  group Inc/Modules/dock_latch
    ../../Inc/Modules/dock_latch/: re_app_dock_latch.h
  group Inc/Modules/ext_rtc
    ../../Inc/Modules/ext_rtc/: re_app_ext_rtc.h
  group Inc/Modules/gear_status
    ../../Inc/Modules/gear_status/: re_app_gear_status.h
  group Inc/Modules/gps_gprs
    ../../Inc/Modules/gps_gprs/: re_app_gps.h re_app_MC60.h re_app_UART_Ring.h
  group Inc/Modules/int_rtc
    ../../Inc/Modules/int_rtc/: re_app_int_rtc.h
  group Inc/Modules/key_position
    ../../Inc/Modules/key_position/: re_app_key_position.h
  group Inc/Modules/main
    ../../Inc/Modules/main/: main.h
  group Inc/Modules/nrf52
    ../../Inc/Modules/nrf52/: re_app_nrf52.h
  group Inc/Modules/obd
    ../../Inc/Modules/obd/: re_app_obd.h
  group Inc/Modules/rev_light
    ../../Inc/Modules/rev_light/: re_app_rev_light.h
  group Inc/Modules/sdcard
    ../../Inc/Modules/sdcard/: re_app_sdcard.h
  group Inc/Modules/speed_info
    ../../Inc/Modules/speed_info/: re_app_speed_info.h
  group Inc/Modules/timers
    ../../Inc/Modules/timers/: re_app_timers.h
  group Inc/SysConfig
    ../../Inc/SysConfig/: re_std_def.h re_sys_clk_config.h stm32f4xx_hal_conf.h
  group Middlewares/Third_Party/FatFs/Src
    ../../Middleware/Third_Party/FatFs/Src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/Third_Party/FatFs/Src/option
    ../../Middleware/Third_Party/FatFs/Src/option/: syscall.c unicode.c
  group Src/EWARM
    ./: startup_stm32f407xx.s
  group Src/Inits
    ../../Src/Inits/: re_can_init.c re_dock_latch_init.c re_gear_init.c re_hal_msp.c re_i2c_init.c re_key_init.c re_lcd_gpio_init.c re_rev_light_init.c re_speed_init.c re_spi_init.c re_thc_off_init.c re_timer_init.c re_uart_init.c
  group Src/ISR
    ../../Src/ISR/: re_can_int_callback.c re_gpio_int_callback.c re_timer_int_callback.c stm32f4xx_it.c
  group Src/Modules/battery_info
    ../../Src/Modules/battery_info/: re_app_battery_info.c
  group Src/Modules/dash_lcd
    ../../Src/Modules/dash_lcd/: re_app_dash_lcd.c re_driver_dash_lcd.c
  group Src/Modules/dock_latch
    ../../Src/Modules/dock_latch/: re_app_dock_latch.c
  group Src/Modules/ext_rtc
    ../../Src/Modules/ext_rtc/: re_app_ext_rtc.c
  group Src/Modules/gear_status
    ../../Src/Modules/gear_status/: re_app_gear_status.c
  group Src/Modules/gps_gprs
    ../../Src/Modules/gps_gprs/: re_app_gps.c re_app_MC60.c re_app_MC60_GNSS.c re_app_MC60_GPRS.c re_app_MC60_TCPIP.c re_app_UART_Ring.c
  group Src/Modules/int_rtc
    ../../Src/Modules/int_rtc/: re_app_int_rtc.c
  group Src/Modules/key_position
    ../../Src/Modules/key_position/: re_app_key_position.c
  group Src/Modules/main
    ../../Src/Modules/main/: main.c
  group Src/Modules/motor_temp
    ../../Src/Modules/motor_temperature/: re_app_motor_temp.c
  group Src/Modules/nrf52
    ../../Src/Modules/nrf52/: re_app_nrf52.c
  group Src/Modules/obd
    ../../Src/Modules/obd/: re_app_obd.c
  group Src/Modules/rev_light
    ../../Src/Modules/rev_light/: re_app_rev_light.c
  group Src/Modules/sdcard
    ../../Src/Modules/sdcard/: bsp_driver_sd.c fatfs.c sd_diskio.c
  group Src/Modules/speed_info
    ../../Src/Modules/speed_info/: re_app_speed_info.c
  group Src/Modules/timers
    ../../Src/Modules/timers/: re_app_timers.c
  group Src/SysConfig
    ../../Src/SysConfig/: re_std_def.c re_sys_clk_config.c
